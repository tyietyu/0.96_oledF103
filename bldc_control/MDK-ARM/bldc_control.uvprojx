# Keil uVision project bldc_control.uvprojx, settings and files
target bldc_control (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: bldc_control +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Foc_control\Algorithm;..\Foc_control\ControlSystem;..\Foc_control\Drivers\AS5600;..\Foc_control\Drivers\Log;..\Foc_control\Drivers\MPU6050;..\Foc_control\Drivers\SSD1306
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Foc_control
    ../Foc_control/Algorithm/: lowpass_filter.c pid.c
    ../Foc_control/ControlSystem/: foc.c foc_hal.c foc_test.c
  group hardware_Drivers
    ../Foc_control/Drivers/AS5600/: as5600.c
    ../Foc_control/Drivers/Log/: log.c
    ../Foc_control/Drivers/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
    ../Foc_control/Drivers/SSD1306/: fonts.c ssd1306.c
software components: CMSIS:CORE 4.3.0
